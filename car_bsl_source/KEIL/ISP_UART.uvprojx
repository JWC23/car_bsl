# Keil uVision project ISP_UART.uvprojx, settings and files
target ISP_UART (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC029LAN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: NUC029xAN_ISP_UART0_P30_P31
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Library\Device\Nuvoton\NUC029xAN\Include;..\Library\CMSIS\Include;..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_NUC029xAN.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/NUC029xAN/Source/: system_NUC029xAN.c
    ../Library/Device/Nuvoton/NUC029xAN/Source/ARM/: startup_NUC029xAN.s
  group User
    ../: FMC_USER.c ISP_USER.c main.c targetdev.c uart_transfer.c utils.c
  group Library
    ../Library/StdDriver/src/: sys.c gpio.c wdt.c fmc.c
software components: CMSIS:CORE 5.1.2
